# Keil uVision project power.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C32 Intel
  cpu: IRAM(0-0xFF) CLOCK(24000000)
  output: power +hex
  c flags: Optimize=8
  group Source Group 1
    ./: STARTUP.A51 power.c
